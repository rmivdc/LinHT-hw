# Repository rmivdc/LinHT-hw

## KiCad design linht-hw.kicad_pcb

Board: 4 copper layers, 45.4 x 95.9 mm, 178 parts (19 on the bottom side), 147 nets.

Parts:
C1, C2, C3, C4, C56, C61: 10n; C_0402_1005Metric
C5, C6, C7, C8, C9, C10, C13, C19, C20, C21, C23, C24, C25, C32, C33, C34, C35, C37, C40, C41, C42, C43, C48, C49, C50, C51, C52, C55, C57, C59, C60: 100n; C_0402_1005Metric
C11: 33p; C_0402_1005Metric
C12: 27p; C_0402_1005Metric
C14, C15: 1n; C_0402_1005Metric
C16, C36, C38, C39, C45, C47, C53: 10u; C_0402_1005Metric
C17, C18, C22: 10u; C_1206_3216Metric
C26: 18p; C_0402_1005Metric
C27: 22p; C_0402_1005Metric
C28, C29, C30, C31: 22u; C_1206_3216Metric
C44: 470n; C_0402_1005Metric
C46, C58: 2u2; C_0402_1005Metric
C54: 1u; C_0402_1005Metric
C68, C69: C_0402_1005Metric
D1, D2, D3, D7: BAT60A; D_SOD-323
D4, D5: LED; LED_0402_1005Metric
D6: LED; LED_Rectangular_W3.0mm_H2.0mm
FB1, FB2, FB3: 220R; L_0805_2012Metric
FL1: LFCN-490+; Filter_Mini-Circuits_FV1206
H2, H4, H5, H6, H7, H8, H9, H10: MountingHole_Pad; MountingHole_2.2mm_M2_DIN965_Pad
IC1: SX1255IWLTRT; QFN50P500X500X80-33N-D
J1: Antenna; Connector_SMA_4x10mm
J2: Battery connector; Connector_01x03_BT-003E
J3: GND spring; TestPoint_Pad_D4.0mm
J4: U.FL_Molex_MCRF_73412-0110_Vertical
J4#2, J15: SPEAKER; TestPoint_Pad_D4.0mm
J5: LCD; Connector_FFC_01x20_P0.75mm
J6, J7, J10: GND; Solder_Pad-1.7x2.2mm
J8: PTT; Solder_Pad-1.7x2.2mm
J9: BTN_2; Solder_Pad-1.7x2.2mm
J11: Keyboard; FPC-SMD_P0.50-16P_FGS-XJ-H2.0
J12: USB_C; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J13: 2.5mm; Jack_2.5mm_PJ-204_nodrill_Horizontal
J14: 3.5mm; Jack_3.5mm_CUI_SJ1-3525N_Modified
L1: 82n; L_0603_1608Metric
L2: 39n; L_0603_1608Metric
L3, L4: 4.7 uH; L_Bourns-SRN6028
Q1, Q2, Q3, Q4, Q5: BSS138; SOT-23
R1: 12k; R_0402_1005Metric
R2: 22k; R_0402_1005Metric
R3, R4: 22R; R_0402_1005Metric
R5, R6, R7, R8, R9, R10, R11, R13, R33, R38, R45, R50, R51: 100R; R_0402_1005Metric
R12, R17, R18, R19, R20, R29, R32: 100k; R_0402_1005Metric
R14: 39k/1%; R_0402_1005Metric
R15: 10k/1%; R_0402_1005Metric
R16: 51k; R_0402_1005Metric
R21: 220k/1%; R_0402_1005Metric
R22, R24: 30k/1%; R_0402_1005Metric
R23: 133k/1%; R_0402_1005Metric
R25, R26, R35, R39, R44: 47k; R_0402_1005Metric
R27: 0R; R_0402_1005Metric
R28, R31: 2k2; R_0402_1005Metric
R30: 150k; R_0402_1005Metric
R34, R36: 10k; R_0402_1005Metric
R37: 10R; R_0402_1005Metric
R40, R41: 220R; R_0402_1005Metric
R42: 150R; R_0402_1005Metric
R43: 150R/0.5W; R_0402_1005Metric
R46, R47: 5k1; R_0402_1005Metric
R48: 1k; R_0402_1005Metric
R49: 15k; R_0402_1005Metric
R63: R_0402_1005Metric
SW2: 10k; Connector_08x09mm_pot_switch
TP1: MICBIAS; TestPoint_Pad_D1.0mm
TP2: HP_{R}; TestPoint_Pad_D1.0mm
TP3: HP_{L}; TestPoint_Pad_D1.0mm
TP4: SPK_{RN}; TestPoint_Pad_D1.0mm
TP5: SPK_{RP}; TestPoint_Pad_D1.0mm
U1: MCM-iMX93
U2: BGS12P2L6; TSLP-6-4
U3, U4: TPS562203; SOT-563
U5: 74AHC1G86; SOT-353_SC-70-5
U6: WM8960; QFN-32-1EP_5x5mm_P0.5mm_EP3.6x3.6mm_ThermalVias
U7: MAX9814; DFN-14-1EP_3x3mm_P0.4mm_EP1.78x2.35mm
U8: USBLC6-2SC6; SOT-23-6
U12: XCVR_LG77L
Y1: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm
Y2: 12.288M; Oscillator_SMD_4Pin_2.0x1.6mm
Y3: Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, C27.1, C29.1, C31.1, C33.1, C34.1, C36.1, C37.1, C60.1, C61.1, FB1.1, IC1.2 (VBATI), IC1.16 (VBAT2), IC1.32 (VBAT3), J5.4, J5.5, J5.19, J11.1, L4.2, R23.1, R25.1, R26.1, R34.2, R36.1, R40.2, R41.2, R49.1, U2.4 (VDD), U12.19, U12.21, Y1.4 (VDD), Y2.1 (Tri-State), Y2.4 (VDD)
+5V: C25.1, D3.1 (K), FB2.2, FB3.2, R16.1, R42.2, U1.4 (V_SOM), U1.6 (V_SOM), U1.11 (V_SOM), U1.15 (V_SOM), U5.5 (VCC), U8.5 (VBUS)
/Audio/I2C_SCL: R25.2, U1.97 (GPIO2_IO[29]), U6.17 (SCLK)
/Audio/I2C_SDA: R26.2, U1.98 (GPIO2_IO[28]), U6.18 (SDIN)
/Audio/I2S_CLK_IN: U1.101 (SAI3_TX_BCLK), U6.12 (BCLK)
/Audio/I2S_DATA_IN: U1.117 (SAI3_TX_DATA[0]), U6.14 (DAC_{DAT})
/Audio/I2S_DATA_OUT: U1.116 (SAI3_RX_DATA[0]), U6.16 (ADC_{DAT})
/Audio/I2S_WS_IN: R27.2, U1.47 (SAI3_TX_SYNC), U6.13 (DAC_{LRC})
/Audio/JACK_DETECT: J13.TN, U6.2 (JD2)
/Audio/MIC_GAIN: U1.67 (GPIO3_IO[6]), U7.10 (GAIN)
/Audio/MIC_IN: C40.1, J14.R, R28.2
/Audio/MIC_SIG: C50.1, C56.1, R31.2
/Audio/SPK_OUT: C54.2, J13.T, R32.1
/Audio/~MIC_MUTE: U1.68 (GPIO3_IO[5]), U7.2 (~SHDN)
/Connectors/DEBUG_DEV_RX: R51.2, U1.64 (UART1_RX)
/Connectors/DEBUG_DEV_TX: R50.2, U1.63 (UART1_TX)
/Connectors/EXT_PTT: R48.1, U1.112 (GPIO3_IO[23)
/Connectors/MIC_IN: J11.13, J14.RN
/Connectors/SWITCH_ON_OFF: Q1.1 (G), R16.2, R19.1, R20.1, SW2.S1, U5.1
/Connectors/USB_DN: R3.2, U8.4 (I/O2)
/Connectors/USB_DP: R4.2, U8.6 (I/O1)
/Connectors/USB_VSENSE: D7.2 (A), J12.A4 (VBUS), J12.A9 (VBUS), J12.B4 (VBUS), J12.B9 (VBUS), R1.2
/Connectors/VOL_POT: SW2.2, U1.10 (VOL_ADC)
/Connectors/xUDN: J12.A7 (D-), J12.B7 (D-), U8.3 (I/O2)
/Connectors/xUDP: J12.A6 (D+), J12.B6 (D+), U8.1 (I/O1)
/Display/DISP_PWM: R33.1, U1.99 (GPIO2_IO[24])
/Display/FLASHLIGHT: R38.1, U1.118 (GPIO2_IO[18])
/Display/LCD_CLK: J5.16, U1.108 (SPI6_SCK)
/Display/LCD_CS: J5.18, U1.129 (GPIO2_IO[0])
/Display/LCD_RS: J5.15, U1.119 (GPIO2_IO[19])
/Display/LCD_SDA: J5.13, U1.128 (SPI6_SOUT)
/Display/LED_A: D4.1 (K), U1.124 (GPIO2_IO[5])
/Display/LED_B: D5.1 (K), U1.125 (GPIO2_IO[4])
/GNSS/RF_IN: C68.1, J4.1, R63.1, U12.1
/GNSS/RST_GNSS: U1.69 (GPIO3_IO[2]), U12.14
/GNSS/WAKEUP_GNSS: U1.70 (GPIO3_IO[1]), U12.13
/Keyboard/D1: J11.12, U1.51 (GPIO4_IO[16])
/Keyboard/D2: J11.11, U1.52 (GPIO4_IO[19])
/Keyboard/D3: J11.10, U1.53 (GPIO4_IO[18])
/Keyboard/D4: J11.9, U1.54 (GPIO4_IO[20])
/Keyboard/D5: J11.8, U1.55 (GPIO4_IO[17])
/Keyboard/D6: J11.7, U1.56 (GPIO4_IO[21])
/Keyboard/D7: J11.6, U1.57 (GPIO4_IO[23])
/Keyboard/D8: J11.5, U1.58 (GPIO4_IO[22])
/Keyboard/D9: J11.4, U1.59 (GPIO4_IO[24])
/Keyboard/KBD_PWM: R45.1, U1.105 (GPIO2_IO[12])
/Keyboard/SIDE_BTN: J9.1, U1.5 (ALT_BOOT_USB), U1.114 (GPIO3_IO[22])
/Keyboard/SIDE_PTT: J8.1, U1.113 (GPIO3_IO[21])
/Power/3V3_EN: C16.1, R13.1, R18.2, U4.5 (EN)
/Power/ON/OFF: Q2.3 (D), U1.3 (ON/OFF)
/Power/PWR_SW: D1.2 (A), U1.102 (GPIO2_IO[14])
/Power/U_BATT_MON: C19.1, R14.2, R15.1, U1.9
/RF/I2S_BB_DATA_IN: R6.2, U1.66 (SAI1_TX_DATA[0])
/RF/I2S_BB_DATA_OUT: R7.2, U1.131 (SAI1_RX_DATA[0])
/RF/I2S_CLK: R5.2, U1.132 (SAI1_TX_BCLK)
/RF/I2S_WS: R8.1, U1.126 (SAI1_TX_SYNC)
/RF/MISO: R10.1, U1.121 (SPI3_SIN)
/RF/MOSI: R9.1, U1.123 (SPI3_SOUT)
/RF/RESET: IC1.9 (RESET), U1.115 (GPIO2_IO[22])
/RF/RF_IN: C14.1, L2.1
/RF/RF_OUT: C11.2, U2.1 (RF_OUT_2)
/RF/RF_SW_CTRL: R12.1, U1.104 (GPIO2_IO[13]), U2.6 (CTRL)
/RF/SPI_SCK: R11.1, U1.122 (SPI3_SCK)
/RF/TCXO_CLK: IC1.8 (XTB), Y1.3 (OUT)
/RF/~CS: IC1.20 (NSS), U1.120 (GPIO2_IO[8])
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, C13.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C25.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.1, C46.2, C47.1, C48.2, C49.2, C51.2, C52.2, C53.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C68.2, C69.2, FL1.2 (GND), FL1.4 (GND), H2.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, IC1.4 (GND_1), IC1.7 (GND_2), IC1.26 (GND_3), IC1.28 (GND_4), IC1.31 (GND_5), IC1.33 (GND_6), J1.2 (Ext), J2.3, J3.1, J4.2, J5.1, J5.3, J5.6, J5.7, J5.8, J5.9, J5.10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
GNSS/UART3_RX: U1.88, U12.16
GNSS/UART3_TX: U1.84, U12.15
unnamed: D1.1 (K), Q1.3 (D), R13.2
unnamed: D2.2 (A), R19.2
unnamed: C22.1, D2.1 (K), R20.2, U5.2
unnamed: C26.1, C28.1, C30.1, C32.1, D3.2 (A), L3.2, R21.1
unnamed: D4.2 (A), R40.1
unnamed: D5.2 (A), R41.1
unnamed: D6.2 (A), R42.1
unnamed: D6.1 (K), Q4.3 (D)
unnamed: D7.1 (K), FB3.1
unnamed: C15.2, FL1.1 (IN)
unnamed: FL1.3 (OUT), J1.1 (In)
unnamed: IC1.10 (CK_OUT), R5.1
unnamed: IC1.23 (DIO2), R8.2
unnamed: IC1.13 (I_IN), R6.1
unnamed: IC1.15 (I_OUT), R7.1
unnamed: IC1.18 (MISO), R10.2
unnamed: IC1.19 (MOSI), R9.2
unnamed: IC1.27 (RFI), L1.2, L2.2
unnamed: C12.1, IC1.29 (RFO_N)
unnamed: C11.1, IC1.30 (RFO_P)
unnamed: IC1.17 (SCK), R11.2
unnamed: C13.1, IC1.25 (VR_ANA2)
unnamed: C9.1, IC1.3 (VR_ANAI)
unnamed: C10.1, IC1.5 (VR_DIG)
unnamed: C7.1, IC1.1 (VR_PA)
unnamed: C17.1, C18.1, C20.1, C21.1, J2.1, R14.1, R17.1, R18.1, U3.1 (VIN), U4.1 (VIN)
unnamed: J4#2.1, U6.23 (SPK_{LN})
unnamed: J5.2, R36.2
unnamed: C59.1, J5.17, R34.1
unnamed: J5.20, R37.2
unnamed: J11.2, R43.1
unnamed: J12.A5 (CC1), R46.2
unnamed: J12.B5 (CC2), R47.2
unnamed: J13.R, R50.1
unnamed: J14.S, R48.2
unnamed: J14.T, R51.1
unnamed: J15.1, U6.25 (SPK_{LP})
unnamed: Q2.1 (G), U5.4
unnamed: Q3.3 (D), R37.1
unnamed: Q3.1 (G), R33.2, R35.1
unnamed: Q4.1 (G), R38.2, R39.1
unnamed: Q5.3 (D), R43.2
unnamed: Q5.1 (G), R44.1, R45.2
unnamed: R49.2, SW2.1
unnamed: R3.1, U1.140 (USB1_DN)
unnamed: R4.1, U1.139 (USB1_DP)
unnamed: R1.1, R2.2, U1.2 (USB1_VBUS_3V3)
unnamed: C15.1, U2.5 (RF_IN)
unnamed: C14.2, U2.3 (RF_OUT_1)
unnamed: R17.2, U3.5 (EN)
unnamed: C23.2, L3.1, U3.2 (SW)
unnamed: C23.1, U3.4 (VBST)
unnamed: C26.2, R21.2, R22.1, U3.6 (VFB)
unnamed: C24.2, L4.1, U4.2 (SW)
unnamed: C24.1, U4.4 (VBST)
unnamed: C27.2, R23.2, R24.1, U4.6 (VFB)
unnamed: TP3.1, U6.31 (HP_{L})
unnamed: TP2.1, U6.29 (HP_{R})
unnamed: C49.1, U6.4 (LINPUT1)
unnamed: C48.1, U6.3 (LINPUT2)
unnamed: C45.2, TP1.1, U6.1 (MICBIAS)
unnamed: C54.1, U6.30 (OUT3)
unnamed: C50.2, U6.5 (RINPUT1)
unnamed: C51.1, U6.6 (RINPUT2)
unnamed: C52.1, U6.7 (RINPUT3)
unnamed: TP4.1, U6.19 (SPK_{RN})
unnamed: TP5.1, U6.22 (SPK_{RP})
unnamed: C53.1, C57.1, FB2.1, U6.21 (VDD_{SPK2}), U6.26 (VDD_{SPK1})
unnamed: C47.2, U6.27 (VMID)
unnamed: R27.1, U6.15 (ADC_{LRC})
unnamed: U6.11 (MCLK), Y2.3 (OUT)
unnamed: C44.1, U7.12 (BIAS)
unnamed: C46.1, U7.3 (CG)
unnamed: C41.1, U7.1 (CT)
unnamed: R28.1, R30.2, U7.13 (MICBIAS)
unnamed: C40.2, U7.8 (MICIN)
unnamed: R31.1, U7.6 (MICOUT)
unnamed: R29.1, R30.1, U7.14 (TH)
VDD: C35.1, C38.1, C39.1, C42.1, C43.1, C55.1, C58.1, FB1.2, U6.8 (VDD_{DC}), U6.10 (VDD_{DB}), U6.32 (VDD_{A}), U7.5 (VDD), U12.20

## Commit log

2025-09-28 Attempt to add GNSS Quectel LG77L module
    Adding rst/wkp lines + board cleanup
    removed lvl shifter and LDO - added passive elements gnss rf-in
